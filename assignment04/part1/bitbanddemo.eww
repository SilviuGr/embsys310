<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\assignment0311-12\ledoneblinker.ewp</path>
    </project>
    <batchBuild />
</workspace>
